* NGSPICE file created from regulator.ext - technology: sky130A

* Top level circuit regulator

X0 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=3.944e+13p pd=2.8186e+08u as=3.886e+13p ps=2.8076e+08u w=8e+06u l=500000u
X1 a_4049_1550# a_4049_1550# a_4049_1550# vin sky130_fd_pr__pfet_01v8_lvt ad=1.45e+12p pd=1.29e+07u as=0p ps=0u w=1e+06u l=1e+06u
X2 a_1908_1483# a_4365_1495# a_4049_1550# vss sky130_fd_pr__nfet_01v8_lvt ad=4.64e+12p pd=4.128e+07u as=2.03e+12p ps=1.806e+07u w=1e+06u l=1e+06u
X3 vss bias bias vss sky130_fd_pr__nfet_01v8_lvt ad=1.74e+12p pd=1.548e+07u as=2.61e+12p ps=2.322e+07u w=1e+06u l=1e+06u
X4 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X5 a_1908_1483# bias vss vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X6 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X7 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X8 bias bias bias vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X9 a_4365_1495# a_10535_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X10 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X11 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X12 a_1908_1483# bias a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X13 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X14 comp vref a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=2.03e+12p pd=1.806e+07u as=0p ps=0u w=1e+06u l=1e+06u
X15 comp comp comp vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X16 a_1908_1483# vref comp vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X17 a_4049_1550# a_4049_1550# a_4049_1550# vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X18 vss bias a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X19 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X20 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X21 vin a_4049_1550# a_4049_1550# vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X22 bias bias bias vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X23 bias bias vss vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X24 comp comp comp vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X25 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X26 a_4049_1550# a_4365_1495# a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X27 vin a_4049_1550# a_4049_1550# vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X28 a_1908_1483# a_4365_1495# a_4049_1550# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X29 comp a_4049_1550# vin vin sky130_fd_pr__pfet_01v8_lvt ad=1.74e+12p pd=1.548e+07u as=0p ps=0u w=1e+06u l=1e+06u
X30 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X31 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X32 vss bias a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X33 enb en vin vin sky130_fd_pr__pfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=400000u
X34 bias bias vss vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X35 a_4049_1550# a_4365_1495# a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X36 bias bias bias vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X37 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X38 vss vss vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X39 comp a_4049_1550# vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X40 enb en vss vss sky130_fd_pr__nfet_01v8_lvt ad=2.9e+11p pd=2.58e+06u as=0p ps=0u w=1e+06u l=400000u
X41 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X42 a_4365_1495# a_10113_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X43 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X44 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X45 a_1908_1483# a_4365_1495# a_4049_1550# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X46 out a_8847_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X47 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X48 comp vref a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X49 a_1908_1483# bias a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X50 comp a_4049_1550# comp vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X51 a_9269_2559# a_10535_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X52 a_1908_1483# vref comp vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X53 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X54 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X55 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X56 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X57 a_4049_1550# a_4365_1495# a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X58 a_4049_1550# a_4049_1550# a_4049_1550# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X59 vss bias bias vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X60 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X61 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X62 a_1908_1483# bias vss vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X63 comp a_4049_1550# comp vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X64 a_1908_1483# a_4365_1495# a_4049_1550# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X65 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X66 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X67 vin a_4049_1550# comp vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X68 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X69 a_9691_2559# a_8425_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X70 a_4049_1550# a_4049_1550# a_4049_1550# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X71 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X72 comp vref a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X73 bias enb vss vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=400000u
X74 vin a_4049_1550# comp vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X75 a_1908_1483# vref comp vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X76 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X77 a_4049_1550# a_4049_1550# vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X78 bias bias bias vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X79 vss vss vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X80 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X81 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X82 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X83 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X84 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X85 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X86 comp en vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=400000u
X87 comp vref a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X88 a_9269_2559# a_8847_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X89 a_1908_1483# bias a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X90 a_4049_1550# a_4049_1550# vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X91 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X92 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X93 a_1908_1483# bias a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X94 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X95 vss a_8425_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X96 a_9691_2559# a_10113_4691# vss sky130_fd_pr__res_xhigh_po w=350000u l=8.5e+06u
X97 out comp sky130_fd_pr__cap_mim_m3_1 l=5e+06u w=5e+06u
X98 a_1908_1483# vref comp vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X99 out comp vin vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
X100 a_4049_1550# a_4365_1495# a_1908_1483# vss sky130_fd_pr__nfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=1e+06u l=1e+06u
X101 vin comp out vin sky130_fd_pr__pfet_01v8_lvt ad=0p pd=0u as=0p ps=0u w=8e+06u l=500000u
C0 vin comp 10.95fF
C1 a_4365_1495# a_4049_1550# 3.67fF
C2 a_4049_1550# comp 4.61fF
C3 vin a_4049_1550# 4.07fF
C4 bias a_1908_1483# 5.06fF
C5 comp out 30.67fF
C6 vin out 52.04fF
C7 a_4365_1495# vref 6.47fF
C8 vref comp 3.66fF
C9 a_4365_1495# comp 6.10fF
C10 a_4049_1550# vss 8.62fF
C11 vref vss 10.91fF
C12 a_4365_1495# vss 13.66fF
C13 a_10113_4691# vss 2.02fF
C14 a_8425_4691# vss 2.02fF
C15 a_1908_1483# vss 3.77fF
C16 bias vss 9.89fF
C17 out vss 12.67fF
C18 enb vss 2.65fF
C19 comp vss 33.22fF
C20 vin vss 74.58fF
.end
