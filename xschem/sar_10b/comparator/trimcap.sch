** sch_path: xschem/sar_10b/comparator/trimcap.sch
**.subckt trimcap cp cn
*.iopin cp
*.iopin cn
c0 net1 cn 2f m=1
c1 cp net1 1f m=1
**.ends
.end
