** sch_path: xschem/user_analog_project_wrapper.sch
**.subckt user_analog_project_wrapper vdda1 vdda2 vssa1 vssa2 vccd1 vccd2 vssd1 vssd2 wb_clk_i
*+ wb_rst_i wbs_stb_i wbs_cyc_i wbs_we_i wbs_sel_i[3],wbs_sel_i[2],wbs_sel_i[1],wbs_sel_i[0]
*+ wbs_dat_i[31],wbs_dat_i[30],wbs_dat_i[29],wbs_dat_i[28],wbs_dat_i[27],wbs_dat_i[26],wbs_dat_i[25],wbs_dat_i[24],wbs_dat_i[23],wbs_dat_i[22],wbs_dat_i[21],wbs_dat_i[20],wbs_dat_i[19],wbs_dat_i[18],wbs_dat_i[17],wbs_dat_i[16],wbs_dat_i[15],wbs_dat_i[14],wbs_dat_i[13],wbs_dat_i[12],wbs_dat_i[11],wbs_dat_i[10],wbs_dat_i[9],wbs_dat_i[8],wbs_dat_i[7],wbs_dat_i[6],wbs_dat_i[5],wbs_dat_i[4],wbs_dat_i[3],wbs_dat_i[2],wbs_dat_i[1],wbs_dat_i[0]
*+ wbs_adr_i[31],wbs_adr_i[30],wbs_adr_i[29],wbs_adr_i[28],wbs_adr_i[27],wbs_adr_i[26],wbs_adr_i[25],wbs_adr_i[24],wbs_adr_i[23],wbs_adr_i[22],wbs_adr_i[21],wbs_adr_i[20],wbs_adr_i[19],wbs_adr_i[18],wbs_adr_i[17],wbs_adr_i[16],wbs_adr_i[15],wbs_adr_i[14],wbs_adr_i[13],wbs_adr_i[12],wbs_adr_i[11],wbs_adr_i[10],wbs_adr_i[9],wbs_adr_i[8],wbs_adr_i[7],wbs_adr_i[6],wbs_adr_i[5],wbs_adr_i[4],wbs_adr_i[3],wbs_adr_i[2],wbs_adr_i[1],wbs_adr_i[0] wbs_ack_o
*+ wbs_dat_o[31],wbs_dat_o[30],wbs_dat_o[29],wbs_dat_o[28],wbs_dat_o[27],wbs_dat_o[26],wbs_dat_o[25],wbs_dat_o[24],wbs_dat_o[23],wbs_dat_o[22],wbs_dat_o[21],wbs_dat_o[20],wbs_dat_o[19],wbs_dat_o[18],wbs_dat_o[17],wbs_dat_o[16],wbs_dat_o[15],wbs_dat_o[14],wbs_dat_o[13],wbs_dat_o[12],wbs_dat_o[11],wbs_dat_o[10],wbs_dat_o[9],wbs_dat_o[8],wbs_dat_o[7],wbs_dat_o[6],wbs_dat_o[5],wbs_dat_o[4],wbs_dat_o[3],wbs_dat_o[2],wbs_dat_o[1],wbs_dat_o[0]
*+ la_data_in[127],la_data_in[126],la_data_in[125],la_data_in[124],la_data_in[123],la_data_in[122],la_data_in[121],la_data_in[120],la_data_in[119],la_data_in[118],la_data_in[117],la_data_in[116],la_data_in[115],la_data_in[114],la_data_in[113],la_data_in[112],la_data_in[111],la_data_in[110],la_data_in[109],la_data_in[108],la_data_in[107],la_data_in[106],la_data_in[105],la_data_in[104],la_data_in[103],la_data_in[102],la_data_in[101],la_data_in[100],la_data_in[99],la_data_in[98],la_data_in[97],la_data_in[96],la_data_in[95],la_data_in[94],la_data_in[93],la_data_in[92],la_data_in[91],la_data_in[90],la_data_in[89],la_data_in[88],la_data_in[87],la_data_in[86],la_data_in[85],la_data_in[84],la_data_in[83],la_data_in[82],la_data_in[81],la_data_in[80],la_data_in[79],la_data_in[78],la_data_in[77],la_data_in[76],la_data_in[75],la_data_in[74],la_data_in[73],la_data_in[72],la_data_in[71],la_data_in[70],la_data_in[69],la_data_in[68],la_data_in[67],la_data_in[66],la_data_in[65],la_data_in[64],la_data_in[63],la_data_in[62],la_data_in[61],la_data_in[60],la_data_in[59],la_data_in[58],la_data_in[57],la_data_in[56],la_data_in[55],la_data_in[54],la_data_in[53],la_data_in[52],la_data_in[51],la_data_in[50],la_data_in[49],la_data_in[48],la_data_in[47],la_data_in[46],la_data_in[45],la_data_in[44],la_data_in[43],la_data_in[42],la_data_in[41],la_data_in[40],la_data_in[39],la_data_in[38],la_data_in[37],la_data_in[36],la_data_in[35],la_data_in[34],la_data_in[33],la_data_in[32],la_data_in[31],la_data_in[30],la_data_in[29],la_data_in[28],la_data_in[27],la_data_in[26],la_data_in[25],la_data_in[24],la_data_in[23],la_data_in[22],la_data_in[21],la_data_in[20],la_data_in[19],la_data_in[18],la_data_in[17],la_data_in[16],la_data_in[15],la_data_in[14],la_data_in[13],la_data_in[12],la_data_in[11],la_data_in[10],la_data_in[9],la_data_in[8],la_data_in[7],la_data_in[6],la_data_in[5],la_data_in[4],la_data_in[3],la_data_in[2],la_data_in[1],la_data_in[0]
*+ la_data_out[127],la_data_out[126],la_data_out[125],la_data_out[124],la_data_out[123],la_data_out[122],la_data_out[121],la_data_out[120],la_data_out[119],la_data_out[118],la_data_out[117],la_data_out[116],la_data_out[115],la_data_out[114],la_data_out[113],la_data_out[112],la_data_out[111],la_data_out[110],la_data_out[109],la_data_out[108],la_data_out[107],la_data_out[106],la_data_out[105],la_data_out[104],la_data_out[103],la_data_out[102],la_data_out[101],la_data_out[100],la_data_out[99],la_data_out[98],la_data_out[97],la_data_out[96],la_data_out[95],la_data_out[94],la_data_out[93],la_data_out[92],la_data_out[91],la_data_out[90],la_data_out[89],la_data_out[88],la_data_out[87],la_data_out[86],la_data_out[85],la_data_out[84],la_data_out[83],la_data_out[82],la_data_out[81],la_data_out[80],la_data_out[79],la_data_out[78],la_data_out[77],la_data_out[76],la_data_out[75],la_data_out[74],la_data_out[73],la_data_out[72],la_data_out[71],la_data_out[70],la_data_out[69],la_data_out[68],la_data_out[67],la_data_out[66],la_data_out[65],la_data_out[64],la_data_out[63],la_data_out[62],la_data_out[61],la_data_out[60],la_data_out[59],la_data_out[58],la_data_out[57],la_data_out[56],la_data_out[55],la_data_out[54],la_data_out[53],la_data_out[52],la_data_out[51],la_data_out[50],la_data_out[49],la_data_out[48],la_data_out[47],la_data_out[46],la_data_out[45],la_data_out[44],la_data_out[43],la_data_out[42],la_data_out[41],la_data_out[40],la_data_out[39],la_data_out[38],la_data_out[37],la_data_out[36],la_data_out[35],la_data_out[34],la_data_out[33],la_data_out[32],la_data_out[31],la_data_out[30],la_data_out[29],la_data_out[28],la_data_out[27],la_data_out[26],la_data_out[25],la_data_out[24],la_data_out[23],la_data_out[22],la_data_out[21],la_data_out[20],la_data_out[19],la_data_out[18],la_data_out[17],la_data_out[16],la_data_out[15],la_data_out[14],la_data_out[13],la_data_out[12],la_data_out[11],la_data_out[10],la_data_out[9],la_data_out[8],la_data_out[7],la_data_out[6],la_data_out[5],la_data_out[4],la_data_out[3],la_data_out[2],la_data_out[1],la_data_out[0]
*+ io_in[26],io_in[25],io_in[24],io_in[23],io_in[22],io_in[21],io_in[20],io_in[19],io_in[18],io_in[17],io_in[16],io_in[15],io_in[14],io_in[13],io_in[12],io_in[11],io_in[10],io_in[9],io_in[8],io_in[7],io_in[6],io_in[5],io_in[4],io_in[3],io_in[2],io_in[1],io_in[0]
*+ io_in_3v3[26],io_in_3v3[25],io_in_3v3[24],io_in_3v3[23],io_in_3v3[22],io_in_3v3[21],io_in_3v3[20],io_in_3v3[19],io_in_3v3[18],io_in_3v3[17],io_in_3v3[16],io_in_3v3[15],io_in_3v3[14],io_in_3v3[13],io_in_3v3[12],io_in_3v3[11],io_in_3v3[10],io_in_3v3[9],io_in_3v3[8],io_in_3v3[7],io_in_3v3[6],io_in_3v3[5],io_in_3v3[4],io_in_3v3[3],io_in_3v3[2],io_in_3v3[1],io_in_3v3[0] user_clock2
*+ io_out[26],io_out[25],io_out[24],io_out[23],io_out[22],io_out[21],io_out[20],io_out[19],io_out[18],io_out[17],io_out[16],io_out[15],io_out[14],io_out[13],io_out[12],io_out[11],io_out[10],io_out[9],io_out[8],io_out[7],io_out[6],io_out[5],io_out[4],io_out[3],io_out[2],io_out[1],io_out[0]
*+ io_oeb[26],io_oeb[25],io_oeb[24],io_oeb[23],io_oeb[22],io_oeb[21],io_oeb[20],io_oeb[19],io_oeb[18],io_oeb[17],io_oeb[16],io_oeb[15],io_oeb[14],io_oeb[13],io_oeb[12],io_oeb[11],io_oeb[10],io_oeb[9],io_oeb[8],io_oeb[7],io_oeb[6],io_oeb[5],io_oeb[4],io_oeb[3],io_oeb[2],io_oeb[1],io_oeb[0]
*+ gpio_analog[17],gpio_analog[16],gpio_analog[15],gpio_analog[14],gpio_analog[13],gpio_analog[12],gpio_analog[11],gpio_analog[10],gpio_analog[9],gpio_analog[8],gpio_analog[7],gpio_analog[6],gpio_analog[5],gpio_analog[4],gpio_analog[3],gpio_analog[2],gpio_analog[1],gpio_analog[0]
*+ gpio_noesd[17],gpio_noesd[16],gpio_noesd[15],gpio_noesd[14],gpio_noesd[13],gpio_noesd[12],gpio_noesd[11],gpio_noesd[10],gpio_noesd[9],gpio_noesd[8],gpio_noesd[7],gpio_noesd[6],gpio_noesd[5],gpio_noesd[4],gpio_noesd[3],gpio_noesd[2],gpio_noesd[1],gpio_noesd[0]
*+ io_analog[10],io_analog[9],io_analog[8],io_analog[7],io_analog[6],io_analog[5],io_analog[4],io_analog[3],io_analog[2],io_analog[1],io_analog[0] io_clamp_high[2],io_clamp_high[1],io_clamp_high[0] io_clamp_low[2],io_clamp_low[1],io_clamp_low[0]
*+ user_irq[2],user_irq[1],user_irq[0]
*+ la_oenb[127],la_oenb[126],la_oenb[125],la_oenb[124],la_oenb[123],la_oenb[122],la_oenb[121],la_oenb[120],la_oenb[119],la_oenb[118],la_oenb[117],la_oenb[116],la_oenb[115],la_oenb[114],la_oenb[113],la_oenb[112],la_oenb[111],la_oenb[110],la_oenb[109],la_oenb[108],la_oenb[107],la_oenb[106],la_oenb[105],la_oenb[104],la_oenb[103],la_oenb[102],la_oenb[101],la_oenb[100],la_oenb[99],la_oenb[98],la_oenb[97],la_oenb[96],la_oenb[95],la_oenb[94],la_oenb[93],la_oenb[92],la_oenb[91],la_oenb[90],la_oenb[89],la_oenb[88],la_oenb[87],la_oenb[86],la_oenb[85],la_oenb[84],la_oenb[83],la_oenb[82],la_oenb[81],la_oenb[80],la_oenb[79],la_oenb[78],la_oenb[77],la_oenb[76],la_oenb[75],la_oenb[74],la_oenb[73],la_oenb[72],la_oenb[71],la_oenb[70],la_oenb[69],la_oenb[68],la_oenb[67],la_oenb[66],la_oenb[65],la_oenb[64],la_oenb[63],la_oenb[62],la_oenb[61],la_oenb[60],la_oenb[59],la_oenb[58],la_oenb[57],la_oenb[56],la_oenb[55],la_oenb[54],la_oenb[53],la_oenb[52],la_oenb[51],la_oenb[50],la_oenb[49],la_oenb[48],la_oenb[47],la_oenb[46],la_oenb[45],la_oenb[44],la_oenb[43],la_oenb[42],la_oenb[41],la_oenb[40],la_oenb[39],la_oenb[38],la_oenb[37],la_oenb[36],la_oenb[35],la_oenb[34],la_oenb[33],la_oenb[32],la_oenb[31],la_oenb[30],la_oenb[29],la_oenb[28],la_oenb[27],la_oenb[26],la_oenb[25],la_oenb[24],la_oenb[23],la_oenb[22],la_oenb[21],la_oenb[20],la_oenb[19],la_oenb[18],la_oenb[17],la_oenb[16],la_oenb[15],la_oenb[14],la_oenb[13],la_oenb[12],la_oenb[11],la_oenb[10],la_oenb[9],la_oenb[8],la_oenb[7],la_oenb[6],la_oenb[5],la_oenb[4],la_oenb[3],la_oenb[2],la_oenb[1],la_oenb[0]
*.iopin vdda1
*.iopin vdda2
*.iopin vssa1
*.iopin vssa2
*.iopin vccd1
*.iopin vccd2
*.iopin vssd1
*.iopin vssd2
*.ipin wb_clk_i
*.ipin wb_rst_i
*.ipin wbs_stb_i
*.ipin wbs_cyc_i
*.ipin wbs_we_i
*.ipin wbs_sel_i[3],wbs_sel_i[2],wbs_sel_i[1],wbs_sel_i[0]
*.ipin
*+ wbs_dat_i[31],wbs_dat_i[30],wbs_dat_i[29],wbs_dat_i[28],wbs_dat_i[27],wbs_dat_i[26],wbs_dat_i[25],wbs_dat_i[24],wbs_dat_i[23],wbs_dat_i[22],wbs_dat_i[21],wbs_dat_i[20],wbs_dat_i[19],wbs_dat_i[18],wbs_dat_i[17],wbs_dat_i[16],wbs_dat_i[15],wbs_dat_i[14],wbs_dat_i[13],wbs_dat_i[12],wbs_dat_i[11],wbs_dat_i[10],wbs_dat_i[9],wbs_dat_i[8],wbs_dat_i[7],wbs_dat_i[6],wbs_dat_i[5],wbs_dat_i[4],wbs_dat_i[3],wbs_dat_i[2],wbs_dat_i[1],wbs_dat_i[0]
*.ipin
*+ wbs_adr_i[31],wbs_adr_i[30],wbs_adr_i[29],wbs_adr_i[28],wbs_adr_i[27],wbs_adr_i[26],wbs_adr_i[25],wbs_adr_i[24],wbs_adr_i[23],wbs_adr_i[22],wbs_adr_i[21],wbs_adr_i[20],wbs_adr_i[19],wbs_adr_i[18],wbs_adr_i[17],wbs_adr_i[16],wbs_adr_i[15],wbs_adr_i[14],wbs_adr_i[13],wbs_adr_i[12],wbs_adr_i[11],wbs_adr_i[10],wbs_adr_i[9],wbs_adr_i[8],wbs_adr_i[7],wbs_adr_i[6],wbs_adr_i[5],wbs_adr_i[4],wbs_adr_i[3],wbs_adr_i[2],wbs_adr_i[1],wbs_adr_i[0]
*.opin wbs_ack_o
*.opin
*+ wbs_dat_o[31],wbs_dat_o[30],wbs_dat_o[29],wbs_dat_o[28],wbs_dat_o[27],wbs_dat_o[26],wbs_dat_o[25],wbs_dat_o[24],wbs_dat_o[23],wbs_dat_o[22],wbs_dat_o[21],wbs_dat_o[20],wbs_dat_o[19],wbs_dat_o[18],wbs_dat_o[17],wbs_dat_o[16],wbs_dat_o[15],wbs_dat_o[14],wbs_dat_o[13],wbs_dat_o[12],wbs_dat_o[11],wbs_dat_o[10],wbs_dat_o[9],wbs_dat_o[8],wbs_dat_o[7],wbs_dat_o[6],wbs_dat_o[5],wbs_dat_o[4],wbs_dat_o[3],wbs_dat_o[2],wbs_dat_o[1],wbs_dat_o[0]
*.ipin
*+ la_data_in[127],la_data_in[126],la_data_in[125],la_data_in[124],la_data_in[123],la_data_in[122],la_data_in[121],la_data_in[120],la_data_in[119],la_data_in[118],la_data_in[117],la_data_in[116],la_data_in[115],la_data_in[114],la_data_in[113],la_data_in[112],la_data_in[111],la_data_in[110],la_data_in[109],la_data_in[108],la_data_in[107],la_data_in[106],la_data_in[105],la_data_in[104],la_data_in[103],la_data_in[102],la_data_in[101],la_data_in[100],la_data_in[99],la_data_in[98],la_data_in[97],la_data_in[96],la_data_in[95],la_data_in[94],la_data_in[93],la_data_in[92],la_data_in[91],la_data_in[90],la_data_in[89],la_data_in[88],la_data_in[87],la_data_in[86],la_data_in[85],la_data_in[84],la_data_in[83],la_data_in[82],la_data_in[81],la_data_in[80],la_data_in[79],la_data_in[78],la_data_in[77],la_data_in[76],la_data_in[75],la_data_in[74],la_data_in[73],la_data_in[72],la_data_in[71],la_data_in[70],la_data_in[69],la_data_in[68],la_data_in[67],la_data_in[66],la_data_in[65],la_data_in[64],la_data_in[63],la_data_in[62],la_data_in[61],la_data_in[60],la_data_in[59],la_data_in[58],la_data_in[57],la_data_in[56],la_data_in[55],la_data_in[54],la_data_in[53],la_data_in[52],la_data_in[51],la_data_in[50],la_data_in[49],la_data_in[48],la_data_in[47],la_data_in[46],la_data_in[45],la_data_in[44],la_data_in[43],la_data_in[42],la_data_in[41],la_data_in[40],la_data_in[39],la_data_in[38],la_data_in[37],la_data_in[36],la_data_in[35],la_data_in[34],la_data_in[33],la_data_in[32],la_data_in[31],la_data_in[30],la_data_in[29],la_data_in[28],la_data_in[27],la_data_in[26],la_data_in[25],la_data_in[24],la_data_in[23],la_data_in[22],la_data_in[21],la_data_in[20],la_data_in[19],la_data_in[18],la_data_in[17],la_data_in[16],la_data_in[15],la_data_in[14],la_data_in[13],la_data_in[12],la_data_in[11],la_data_in[10],la_data_in[9],la_data_in[8],la_data_in[7],la_data_in[6],la_data_in[5],la_data_in[4],la_data_in[3],la_data_in[2],la_data_in[1],la_data_in[0]
*.opin
*+ la_data_out[127],la_data_out[126],la_data_out[125],la_data_out[124],la_data_out[123],la_data_out[122],la_data_out[121],la_data_out[120],la_data_out[119],la_data_out[118],la_data_out[117],la_data_out[116],la_data_out[115],la_data_out[114],la_data_out[113],la_data_out[112],la_data_out[111],la_data_out[110],la_data_out[109],la_data_out[108],la_data_out[107],la_data_out[106],la_data_out[105],la_data_out[104],la_data_out[103],la_data_out[102],la_data_out[101],la_data_out[100],la_data_out[99],la_data_out[98],la_data_out[97],la_data_out[96],la_data_out[95],la_data_out[94],la_data_out[93],la_data_out[92],la_data_out[91],la_data_out[90],la_data_out[89],la_data_out[88],la_data_out[87],la_data_out[86],la_data_out[85],la_data_out[84],la_data_out[83],la_data_out[82],la_data_out[81],la_data_out[80],la_data_out[79],la_data_out[78],la_data_out[77],la_data_out[76],la_data_out[75],la_data_out[74],la_data_out[73],la_data_out[72],la_data_out[71],la_data_out[70],la_data_out[69],la_data_out[68],la_data_out[67],la_data_out[66],la_data_out[65],la_data_out[64],la_data_out[63],la_data_out[62],la_data_out[61],la_data_out[60],la_data_out[59],la_data_out[58],la_data_out[57],la_data_out[56],la_data_out[55],la_data_out[54],la_data_out[53],la_data_out[52],la_data_out[51],la_data_out[50],la_data_out[49],la_data_out[48],la_data_out[47],la_data_out[46],la_data_out[45],la_data_out[44],la_data_out[43],la_data_out[42],la_data_out[41],la_data_out[40],la_data_out[39],la_data_out[38],la_data_out[37],la_data_out[36],la_data_out[35],la_data_out[34],la_data_out[33],la_data_out[32],la_data_out[31],la_data_out[30],la_data_out[29],la_data_out[28],la_data_out[27],la_data_out[26],la_data_out[25],la_data_out[24],la_data_out[23],la_data_out[22],la_data_out[21],la_data_out[20],la_data_out[19],la_data_out[18],la_data_out[17],la_data_out[16],la_data_out[15],la_data_out[14],la_data_out[13],la_data_out[12],la_data_out[11],la_data_out[10],la_data_out[9],la_data_out[8],la_data_out[7],la_data_out[6],la_data_out[5],la_data_out[4],la_data_out[3],la_data_out[2],la_data_out[1],la_data_out[0]
*.ipin
*+ io_in[26],io_in[25],io_in[24],io_in[23],io_in[22],io_in[21],io_in[20],io_in[19],io_in[18],io_in[17],io_in[16],io_in[15],io_in[14],io_in[13],io_in[12],io_in[11],io_in[10],io_in[9],io_in[8],io_in[7],io_in[6],io_in[5],io_in[4],io_in[3],io_in[2],io_in[1],io_in[0]
*.ipin
*+ io_in_3v3[26],io_in_3v3[25],io_in_3v3[24],io_in_3v3[23],io_in_3v3[22],io_in_3v3[21],io_in_3v3[20],io_in_3v3[19],io_in_3v3[18],io_in_3v3[17],io_in_3v3[16],io_in_3v3[15],io_in_3v3[14],io_in_3v3[13],io_in_3v3[12],io_in_3v3[11],io_in_3v3[10],io_in_3v3[9],io_in_3v3[8],io_in_3v3[7],io_in_3v3[6],io_in_3v3[5],io_in_3v3[4],io_in_3v3[3],io_in_3v3[2],io_in_3v3[1],io_in_3v3[0]
*.ipin user_clock2
*.opin
*+ io_out[26],io_out[25],io_out[24],io_out[23],io_out[22],io_out[21],io_out[20],io_out[19],io_out[18],io_out[17],io_out[16],io_out[15],io_out[14],io_out[13],io_out[12],io_out[11],io_out[10],io_out[9],io_out[8],io_out[7],io_out[6],io_out[5],io_out[4],io_out[3],io_out[2],io_out[1],io_out[0]
*.opin
*+ io_oeb[26],io_oeb[25],io_oeb[24],io_oeb[23],io_oeb[22],io_oeb[21],io_oeb[20],io_oeb[19],io_oeb[18],io_oeb[17],io_oeb[16],io_oeb[15],io_oeb[14],io_oeb[13],io_oeb[12],io_oeb[11],io_oeb[10],io_oeb[9],io_oeb[8],io_oeb[7],io_oeb[6],io_oeb[5],io_oeb[4],io_oeb[3],io_oeb[2],io_oeb[1],io_oeb[0]
*.iopin
*+ gpio_analog[17],gpio_analog[16],gpio_analog[15],gpio_analog[14],gpio_analog[13],gpio_analog[12],gpio_analog[11],gpio_analog[10],gpio_analog[9],gpio_analog[8],gpio_analog[7],gpio_analog[6],gpio_analog[5],gpio_analog[4],gpio_analog[3],gpio_analog[2],gpio_analog[1],gpio_analog[0]
*.iopin
*+ gpio_noesd[17],gpio_noesd[16],gpio_noesd[15],gpio_noesd[14],gpio_noesd[13],gpio_noesd[12],gpio_noesd[11],gpio_noesd[10],gpio_noesd[9],gpio_noesd[8],gpio_noesd[7],gpio_noesd[6],gpio_noesd[5],gpio_noesd[4],gpio_noesd[3],gpio_noesd[2],gpio_noesd[1],gpio_noesd[0]
*.iopin
*+ io_analog[10],io_analog[9],io_analog[8],io_analog[7],io_analog[6],io_analog[5],io_analog[4],io_analog[3],io_analog[2],io_analog[1],io_analog[0]
*.iopin io_clamp_high[2],io_clamp_high[1],io_clamp_high[0]
*.iopin io_clamp_low[2],io_clamp_low[1],io_clamp_low[0]
*.opin user_irq[2],user_irq[1],user_irq[0]
*.ipin
*+ la_oenb[127],la_oenb[126],la_oenb[125],la_oenb[124],la_oenb[123],la_oenb[122],la_oenb[121],la_oenb[120],la_oenb[119],la_oenb[118],la_oenb[117],la_oenb[116],la_oenb[115],la_oenb[114],la_oenb[113],la_oenb[112],la_oenb[111],la_oenb[110],la_oenb[109],la_oenb[108],la_oenb[107],la_oenb[106],la_oenb[105],la_oenb[104],la_oenb[103],la_oenb[102],la_oenb[101],la_oenb[100],la_oenb[99],la_oenb[98],la_oenb[97],la_oenb[96],la_oenb[95],la_oenb[94],la_oenb[93],la_oenb[92],la_oenb[91],la_oenb[90],la_oenb[89],la_oenb[88],la_oenb[87],la_oenb[86],la_oenb[85],la_oenb[84],la_oenb[83],la_oenb[82],la_oenb[81],la_oenb[80],la_oenb[79],la_oenb[78],la_oenb[77],la_oenb[76],la_oenb[75],la_oenb[74],la_oenb[73],la_oenb[72],la_oenb[71],la_oenb[70],la_oenb[69],la_oenb[68],la_oenb[67],la_oenb[66],la_oenb[65],la_oenb[64],la_oenb[63],la_oenb[62],la_oenb[61],la_oenb[60],la_oenb[59],la_oenb[58],la_oenb[57],la_oenb[56],la_oenb[55],la_oenb[54],la_oenb[53],la_oenb[52],la_oenb[51],la_oenb[50],la_oenb[49],la_oenb[48],la_oenb[47],la_oenb[46],la_oenb[45],la_oenb[44],la_oenb[43],la_oenb[42],la_oenb[41],la_oenb[40],la_oenb[39],la_oenb[38],la_oenb[37],la_oenb[36],la_oenb[35],la_oenb[34],la_oenb[33],la_oenb[32],la_oenb[31],la_oenb[30],la_oenb[29],la_oenb[28],la_oenb[27],la_oenb[26],la_oenb[25],la_oenb[24],la_oenb[23],la_oenb[22],la_oenb[21],la_oenb[20],la_oenb[19],la_oenb[18],la_oenb[17],la_oenb[16],la_oenb[15],la_oenb[14],la_oenb[13],la_oenb[12],la_oenb[11],la_oenb[10],la_oenb[9],la_oenb[8],la_oenb[7],la_oenb[6],la_oenb[5],la_oenb[4],la_oenb[3],la_oenb[2],la_oenb[1],la_oenb[0]
xtop la_data_in[81] dvdd gpio_analog[3] la_data_out[70] la_data_out[71] la_data_out[72]
+ la_data_out[73] la_data_out[74] la_data_out[75] la_data_out[76] la_data_out[77] la_data_out[78] la_data_out[79]
+ la_data_out[80] la_data_in[66] gpio_analog[2] la_data_in[82] avdd la_data_in[69] vdda1 vssa1 la_data_in[62] clksys
+ la_data_in[63] gpio_analog[4] gpio_analog[5] la_data_in[67] la_data_in[68] la_data_in[61] gpio_analog[6]
+ la_data_in[42] la_data_in[43] la_data_in[44] avss dvss la_data_in[60] la_data_in[45] la_data_in[59] la_data_in[46]
+ la_data_in[58] la_data_in[47] la_data_in[57] la_data_in[48] la_data_in[56] la_data_in[49] la_data_in[55]
+ la_data_in[50] la_data_in[54] la_data_in[51] la_data_in[53] la_data_in[52] top
xsar vdda2 vdda2 vssa2 la_data_out[26] la_data_out[27] la_data_out[28] la_data_out[29]
+ la_data_out[30] la_data_out[31] la_data_out[32] la_data_out[33] la_data_out[34] la_data_out[35] gpio_analog[11]
+ vssa2 gpio_analog[7] gpio_analog[10] la_data_in[23] la_data_out[25] la_data_in[24] la_data_in[22] sar
XC1[447] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[446] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[445] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[444] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[443] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[442] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[441] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[440] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[439] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[438] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[437] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[436] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[435] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[434] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[433] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[432] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[431] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[430] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[429] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[428] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[427] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[426] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[425] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[424] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[423] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[422] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[421] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[420] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[419] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[418] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[417] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[416] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[415] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[414] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[413] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[412] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[411] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[410] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[409] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[408] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[407] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[406] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[405] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[404] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[403] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[402] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[401] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[400] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[399] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[398] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[397] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[396] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[395] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[394] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[393] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[392] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[391] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[390] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[389] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[388] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[387] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[386] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[385] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[384] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[383] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[382] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[381] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[380] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[379] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[378] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[377] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[376] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[375] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[374] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[373] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[372] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[371] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[370] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[369] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[368] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[367] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[366] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[365] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[364] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[363] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[362] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[361] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[360] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[359] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[358] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[357] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[356] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[355] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[354] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[353] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[352] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[351] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[350] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[349] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[348] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[347] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[346] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[345] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[344] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[343] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[342] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[341] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[340] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[339] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[338] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[337] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[336] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[335] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[334] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[333] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[332] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[331] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[330] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[329] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[328] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[327] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[326] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[325] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[324] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[323] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[322] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[321] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[320] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[319] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[318] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[317] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[316] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[315] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[314] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[313] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[312] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[311] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[310] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[309] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[308] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[307] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[306] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[305] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[304] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[303] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[302] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[301] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[300] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[299] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[298] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[297] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[296] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[295] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[294] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[293] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[292] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[291] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[290] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[289] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[288] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[287] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[286] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[285] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[284] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[283] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[282] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[281] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[280] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[279] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[278] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[277] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[276] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[275] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[274] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[273] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[272] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[271] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[270] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[269] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[268] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[267] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[266] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[265] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[264] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[263] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[262] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[261] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[260] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[259] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[258] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[257] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[256] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[255] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[254] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[253] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[252] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[251] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[250] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[249] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[248] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[247] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[246] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[245] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[244] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[243] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[242] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[241] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[240] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[239] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[238] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[237] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[236] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[235] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[234] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[233] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[232] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[231] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[230] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[229] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[228] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[227] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[226] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[225] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[224] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[223] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[222] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[221] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[220] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[219] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[218] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[217] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[216] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[215] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[214] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[213] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[212] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[211] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[210] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[209] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[208] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[207] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[206] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[205] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[204] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[203] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[202] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[201] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[200] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[199] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[198] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[197] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[196] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[195] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[194] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[193] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[192] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[191] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[190] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[189] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[188] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[187] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[186] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[185] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[184] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[183] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[182] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[181] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[180] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[179] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[178] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[177] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[176] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[175] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[174] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[173] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[172] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[171] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[170] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[169] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[168] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[167] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[166] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[165] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[164] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[163] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[162] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[161] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[160] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[159] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[158] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[157] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[156] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[155] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[154] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[153] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[152] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[151] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[150] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[149] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[148] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[147] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[146] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[145] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[144] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[143] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[142] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[141] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[140] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[139] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[138] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[137] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[136] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[135] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[134] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[133] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[132] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[131] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[130] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[129] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[128] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[127] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[126] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[125] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[124] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[123] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[122] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[121] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[120] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[119] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[118] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[117] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[116] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[115] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[114] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[113] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[112] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[111] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[110] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[109] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[108] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[107] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[106] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[105] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[104] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[103] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[102] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[101] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[100] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[99] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[98] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[97] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[96] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[95] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[94] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[93] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[92] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[91] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[90] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[89] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[88] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[87] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[86] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[85] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[84] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[83] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[82] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[81] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[80] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[79] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[78] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[77] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[76] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[75] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[74] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[73] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[72] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[71] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[70] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[69] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[68] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[67] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[66] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[65] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[64] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[63] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[62] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[61] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[60] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[59] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[58] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[57] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[56] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[55] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[54] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[53] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[52] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[51] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[50] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[49] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[48] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[47] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[46] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[45] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[44] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[43] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[42] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[41] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[40] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[39] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[38] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[37] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[36] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[35] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[34] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[33] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[32] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[31] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[30] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[29] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[28] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[27] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[26] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[25] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[24] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[23] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[22] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[21] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[20] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[19] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[18] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[17] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[16] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[15] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[14] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[13] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[12] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[11] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[10] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[9] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[8] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[7] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[6] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[5] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[4] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[3] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[2] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[1] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
XC1[0] vdda2 vssa2 sky130_fd_pr__cap_mim_m3_2 W=30 L=30 MF=1 m=1
**.ends
.end
